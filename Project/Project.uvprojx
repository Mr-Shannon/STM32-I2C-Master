# Keil uVision project Project.uvprojx, settings and files
target I2CtoUART (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Application;..\Drivers;..\Library\Include;..\Library\StdPeriph_Driver\inc;..\Library\StdPeriph_Driver\templates
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ../Application/: main.c bsp.c batell.c tools.c
  group Driver
    ../Drivers/: uart.c i2c.c
  group Library
    ../Library/Source/ARM/: startup_stm32f10x_hd.s
    ../Library/Source/: system_stm32f10x.c
    ../Library/StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_i2c.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
